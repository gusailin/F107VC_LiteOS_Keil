# Keil uVision project F107VC_LiteOS.uvprojx, settings and files
target F107VC_LiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F107VC_LiteOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC,HSE_VALUE=50000000,LOS_KERNEL_DEBUG_OUT
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\OS_CONFIG;..\Middlewares\LiteOS\arch\arm\arm-m\include;..\Middlewares\LiteOS\kernel\include;..\Middlewares\LiteOS\kernel\base\include;..\Middlewares\LiteOS\examples\include;..\Components\net\lwip\lwip-2.0.3\src\include;..\Components\net\lwip\lwip_port\arch;..\Components\net\lwip\lwip_port\OS;..\Components\net\lwip\lwip_port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Middleware/LiteOS/arch
    ../Middlewares/LiteOS/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
    ../Middlewares/LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group Middleware/LiteOS/kernel
    ../Middlewares/LiteOS/kernel/: los_init.c
    ../Middlewares/LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../Middlewares/LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../Middlewares/LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../Middlewares/LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../Middlewares/LiteOS/kernel/base/mem/membox/: los_membox.c
    ../Middlewares/LiteOS/kernel/base/misc/: los_misc.c
    ../Middlewares/LiteOS/kernel/base/om/: los_err.c
  group Examples
    ../Middlewares/LiteOS/examples/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_demo_entry.c los_inspect_entry.c
  group Application/User
    ../Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c lwip.c bsp_eth.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_eth.c stm32f1xx_hal_iwdg.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Components/net/LwIP
    ../Components/net/lwip/lwip_port/OS/: ethernetif.c sys_arch.c
    ../Components/net/lwip/lwip-2.0.3/src/api/: tcpip.c api_lib.c netbuf.c netifapi.c netdb.c api_msg.c err.c sockets.c
    ../Components/net/lwip/lwip-2.0.3/src/core/: stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c init.c mem.c memp.c netif.c pbuf.c raw.c dns.c def.c inet_chksum.c ip.c timeouts.c
    ../Components/net/lwip/lwip-2.0.3/src/core/ipv4/: dhcp.c autoip.c icmp.c igmp.c ip4_addr.c ip4_frag.c ip4.c etharp.c
    ../Components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c
software components: CMSIS:CORE 5.2.0
