<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F107VC_LiteOS.ewp</path>
  </project>
  <batchBuild />
</workspace>
